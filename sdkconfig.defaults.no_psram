## sdkconfig.defaults.no_psram
```kconfig
# CONFIG_SPIRAM is not set
# CONFIG_ESP32_SPIRAM_SUPPORT is not set
# CONFIG_SPIRAM_SUPPORT is not set
```
